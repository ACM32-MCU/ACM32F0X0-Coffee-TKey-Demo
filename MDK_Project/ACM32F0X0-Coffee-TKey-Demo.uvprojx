# Keil uVision project ACM32F0X0-Coffee-TKey-Demo.uvprojx, settings and files
target Coffee-Tkey (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ACM32F070CBT7 Aisinochip
  pack: Aisinochip.ACM32F0X0.1.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Coffee_Tkey +hex
  AfterMake: fromelf.exe --bin --output ./Outputs/Coffee_Tkey.bin ./Outputs/Coffee_Tkey.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\Core_Drivers\HAL_Driver\Src;..\Source_Code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CoreDriver/CMSIS
    ../Core_Drivers/CMSIS/: core_cm0.h
  group CoreDriver/Device
    ../Core_Drivers/Device/: ACM32F0x0.h Startup_ACM32F0x0.s System_ACM32F0x0.c System_ACM32F0x0.h
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Inc/: ACM32Fxx_HAL.h
    ../Core_Drivers/HAL_Driver/Src/: HAL_DMA.c HAL_EFLASH.c HAL_EFlash_EX.lib HAL_GPIO.c HAL_UART.c HAL_TKEY.c HAL_TIMER.c
  group SourceCode
    ../Source_Code/: ac_fifo.c ac_fifo.h led.c led.h main.c main.h TouchKey.c TouchKey.h
